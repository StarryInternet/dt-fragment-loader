## Kconfig
```kconfig
config D3_OVERLAY_LOADER
	tristate "Overlay Loader"
	help
	  D3 A driver that will apply device tree based on kernel parameters.
```
